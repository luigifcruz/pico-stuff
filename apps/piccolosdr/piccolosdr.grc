options:
  parameters:
    author: Luigi Cruz
    copyright: MIT
    generate_options: qt_gui
    id: piccolosdr
    output_language: python
    title: PiccoloSDR
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 3.3 / 255.0
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: grnet_udp_source_0
  id: grnet_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notifyMissed: 'False'
    payloadsize: '1472'
    port: '7778'
    srcZeros: 'False'
    type: byte
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [grnet_udp_source_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
